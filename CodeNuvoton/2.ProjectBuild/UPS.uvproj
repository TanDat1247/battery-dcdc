# Keil uVision project UPS.uvproj, settings and files
target UPS (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GPIO +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\1.LibNuvoton\Include
  group MainSource
    ./Code/: main.c initsystem.c pjcommon.h
  group Startup
    ../1.LibNuvoton/Startup/: STARTUP.A51
